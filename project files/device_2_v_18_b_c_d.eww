<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\v.18.00\device_2_v_18_11_0_0.ewp</path>
    </project>
    <batchBuild />
</workspace>
